# IAR project TestEcu.ewp, settings and files
configuration Release (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\..\Src; ..\..\..\Src\ByteStuffing\Inc; ..\..\..\Src\ByteStuffing\Src; ..\..\..\Src\Crc\Inc; ..\..\..\Src\Crc\Src; ..\..\..\Src\DataPacking\Inc; ..\..\..\Src\DataPacking\Src; ..\..\..\Src\Queue\Inc; ..\..\..\Src\Queue\Src; ..\..\Src\ByteStuffing\Inc; ..\..\Src\ByteStuffing\Src; ..\..\Src\Crc\Inc; ..\..\Src\Crc\Src; ..\..\Src\DataPacking\Inc; ..\..\Src\DataPacking\Src; ..\..\Src\Queue\Inc; ..\..\Src\Queue\Src
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\Src\TestFunction\Inc; ..\..\Src\TestFunction\Src
  OBJCOPY.OOCOutputFile: TestEcu.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkAdditionalLibs: ..\..\..\Prj\IAR\Library\Exe\LibEcu.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: main.c
  group Inc
    ../../Src/ByteStuffing/Inc/: eCU_BSTFBUNSTFTST.h eCU_BSTFTST.h eCU_BUSTFTST.h
    ../../Src/Queue/Inc/: eCU_CIRQTST.h
    ../../Src/Crc/Inc/: eCU_CRCDTST.h eCU_CRCTST.h
    ../../Src/DataPacking/Inc/: eCU_DPKDUNPKTST.h eCU_DPKTST.h eCU_DUNPKTST.h
  group Src
    ../../Src/ByteStuffing/Src/: eCU_BSTFBUNSTFTST.c eCU_BSTFTST.c eCU_BUSTFTST.c
    ../../Src/Queue/Src/: eCU_CIRQTST.c
    ../../Src/Crc/Src/: eCU_CRCDTST.c eCU_CRCTST.c
    ../../Src/DataPacking/Src/: eCU_DPKDUNPKTST.c eCU_DPKTST.c eCU_DUNPKTST.c
