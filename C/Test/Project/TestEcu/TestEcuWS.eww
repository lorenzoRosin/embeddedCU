<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\LibEcu\LibEcu.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\TestEcu.ewp</path>
    </project>
    <batchBuild />
</workspace>
