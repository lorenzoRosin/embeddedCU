# IAR project LibEcu.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\..\Code\Inc; ..\..\..\Code\Src
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  group Inc
    ../../../Code/Inc/: eCUByteStuffer.h eCUByteStuffer_prv.h eCUByteUnStuffer.h eCUByteUnStuffer_prv.h eCUCircularQueue.h eCUCrc.h eCUCrcDigest.h eCUDataPack.h eCUDataUnPack.h eCUStandardType.h eCUType.h
  group Src
    ../../../Code/Src/: eCUByteStuffer.c eCUByteUnStuffer.c eCUCircularQueue.c eCUCrc.c eCUCrcDigest.c eCUDataPack.c eCUDataUnPack.c
