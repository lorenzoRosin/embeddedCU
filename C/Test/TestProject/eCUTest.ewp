# IAR project eCUTest.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\Code\Inc; ..\..\Code\Src; ..\TestFunction\Inc; ..\TestFunction\Src
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: eCUTest.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group eCU/Inc
    ../../Code/Inc/: eCUByteStuffer.h eCUByteStuffer_prv.h eCUByteUnStuffer.h eCUByteUnStuffer_prv.h eCUCircularQueue.h eCUCrc.h eCUCrcDigest.h eCUDataPack.h eCUDataUnPack.h eCUStandardType.h eCUType.h
  group eCU/Src
    ../../Code/Src/: eCUByteStuffer.c eCUByteUnStuffer.c eCUCircularQueue.c eCUCrc.c eCUCrcDigest.c eCUDataPack.c eCUDataUnPack.c
  group Test
    ./: main.c
  group Test/Inc
    ../TestFunction/Inc/: eCUByteStufferTest.h eCUByteUnStufferTest.h eCUCircularQueueTest.h eCUCrcDigestTest.h eCUCrcTest.h eCUDataPackTest.h eCUDataPackUnPackTest.h eCUDataStuffUnStuffTest.h eCUDataUnPackTest.h
  group Test/Src
    ../TestFunction/Src/: eCUByteStufferTest.c eCUByteUnStufferTest.c eCUCircularQueueTest.c eCUCrcDigestTest.c eCUCrcTest.c eCUDataPackTest.c eCUDataPackUnPackTest.c eCUDataStuffUnStuffTest.c eCUDataUnPackTest.c
