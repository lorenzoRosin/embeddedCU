# IAR project LibEcu.ewp, settings and files
configuration Library (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\Src; ..\..\Src\ByteStuffing\Inc; ..\..\Src\ByteStuffing\Src; ..\..\Src\Crc\Inc; ..\..\Src\Crc\Src; ..\..\Src\DataPacking\Inc; ..\..\Src\DataPacking\Src; ..\..\Src\Queue\Inc; ..\..\Src\Queue\Src
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  group Inc
    ../../Src/ByteStuffing/Inc/: eCU_BSTF.h eCU_BSTFPRV.h eCU_BUNSTF.h eCU_BUNSTFPRV.h
    ../../Src/Queue/Inc/: eCU_CIRQ.h
    ../../Src/Crc/Inc/: eCU_CRC.h eCU_CRCD.h
    ../../Src/DataPacking/Inc/: eCU_DPK.h eCU_DUNPK.h
    ../../Src/: eCU_STANDARDTYPE.h eCU_TYPE.h
  group Src
    ../../Src/ByteStuffing/Src/: eCU_BSTF.c eCU_BUNSTF.c
    ../../Src/Queue/Src/: eCU_CIRQ.c
    ../../Src/Crc/Src/: eCU_CRC.c eCU_CRCD.c
    ../../Src/DataPacking/Src/: eCU_DPK.c eCU_DUNPK.c
